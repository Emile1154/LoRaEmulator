options:
  parameters:
    author: Emile
    category: LoRaPHY
    generate_options: hb
    id: LoRa
    output_language: python
    title: DeviceLoRa
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    comment: Bandwidth
    value: '125000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 868.1e6
  states: {}
- name: cr
  id: variable
  parameters:
    comment: |-
      Coding
      Rate
    value: '2'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: ldro
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: pay_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: preamb_len
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: sf
  id: variable
  parameters:
    comment: |-
      Spreading 
      Factor
    value: '7'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    output_crc_check: 'False'
    print_rx_msg: '1'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'False'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: bw
    center_freq: int(center_freq)
    impl_head: impl_head
    os_factor: int(samp_rate/bw)
    preamb_len: preamb_len
    sf: sf
    show_log_port: 'False'
    sync_word: '18'
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: sf
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: sf
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
    ldro: ldro
    pay_len: pay_len
    print_header: 'True'
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: ldro
    sf: sf
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: bw
    frame_zero_padd: int(20*2**sf*samp_rate/bw)
    preamb_len: preamb_len
    samp_rate: samp_rate
    sf: sf
    sync_words: '0x12'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'False'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'False'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: sig_tx
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: msg_rx
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: sig_rx
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: msg_tx
    optional: 'True'
    type: message
  states: {}

connections:
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_crc_verif_0, msg, pad_sink_1, in]
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', pad_sink_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [pad_source_0, '0', lora_sdr_frame_sync_0, '0']
- [pad_source_1, out, lora_sdr_whitening_0, msg]

metadata:
  file_format: 1
  grc_version: 3.10.11.0
